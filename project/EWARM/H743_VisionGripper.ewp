# IAR project H743_VisionGripper.ewp, settings and files
configuration H743_VisionGripper (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../App; ../App/platform; ../App/platform/boards/lxb743zi_p1; ../App/bsp; ../App/config; ../App/drivers/Servo; ../App/drivers/display; ../App/modules/claw_core; ../App/modules/shared_state; ../App/protocol; ../App/modules/servo_p3; ../App/vendor/lcd; ../App/vendor/camera; ../App/vendor/qspi; ../App/vendor/sd; ../App/modules/integration; ../App/modules/motor; ../App/modules/ui; ../Middlewares/FatFs; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: H743_VisionGripper.hex
  ILINK.IlinkOutputFile: H743_VisionGripper.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration H743_VisionGripper_NoCamera (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H743xx; BOARD_ENABLE_CAMERA=0
configuration H743_VisionGripper_OV2640 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H743xx; BOARD_CAMERA_SENSOR=2640
  group Application/Core
    ../Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/App
    ../App/: HAL_H.h app_main.c app_main.h
  group Application/App/bsp
    ../App/bsp/: bsp_bluetooth.c bsp_bluetooth.h bsp_key.c bsp_key.h tim.c tim.h
  group Application/App/config
    ../App/config/: feature_config.c feature_config.h feetech_sts_register.c feetech_sts_register.h
  group Application/App/drivers/display
    ../App/drivers/display/: screen_display.h
  group Application/App/drivers/servo
    ../App/drivers/Servo/: feetech_sts_bus.c feetech_sts_bus.h feetech_sts_command.c feetech_sts_command.h feetech_sts_control.c feetech_sts_control.h feetech_sts_port.c feetech_sts_port.h pwm_servo_control.c pwm_servo_control.h
  group Application/App/modules/claw_core
    ../App/modules/claw_core/: claw_host_protocol.c claw_host_protocol.h claw_limit_storage.h
  group Application/App/modules/shared_state
    ../App/modules/shared_state/: shared_state.c shared_state.h
  group Application/App/modules/servo_p3
    ../App/modules/servo_p3/: servo_p3.c servo_p3.h
  group Application/App/protocol
    ../App/protocol/: vofa_protocol.c vofa_protocol.h
  group Application/App/platform
    ../App/platform/: board_led.c board_led.h host_diagnostics.c host_diagnostics.h platform_hal.h board_resources.c board_gpio.c board_nv_storage.c board_resources.h board_uart.c board_uart.h uart_router.c
    ../App/platform/boards/lxb743zi_p1/: board_config.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Integrated peripherals
    ../App/vendor/camera/: dcmi_ov2640.c dcmi_ov5640.c sccb.c
    ../App/vendor/lcd/: lcd_fonts.c lcd_image.c lcd_spi_154.c
    ../App/vendor/qspi/: qspi_w25q64.c
    ../App/vendor/sd/: sdmmc_sd.c
    ../Middlewares/FatFs/: ff.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../USB_DEVICE/App/: usbd_cdc_if.c usbd_desc.c usb_device.c
    ../USB_DEVICE/Target/: usbd_conf.c
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
    ../App/platform/: board_peripherals.c board_storage.c board_camera.c usb_console.c claw_limit_storage_h7.c
    ../App/modules/integration/: integration_service.c integration_console.c vendor_log.c
  group MG310 motor
    ../App/modules/motor/: motor_control.c motor_service.c motor_plot.c
    ../App/platform/: board_motor.c
  group PC vision link
    ../App/platform/: vision_link.c
  group Screen UI
    ../App/modules/ui/: ui_core.c ui_input.c ui_port.c ui_service.c ui_profile.c ui_profile_store.c ui_settings.c
