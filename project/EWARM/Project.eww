<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\H743_VisionGripper.ewp</path>
  </project>
  <batchBuild />
</workspace>
